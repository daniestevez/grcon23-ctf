options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: dvbs2_iqfile
    output_language: python
    run_options: run
  states: {}

blocks:
- name: rolloff
  id: variable
  parameters:
    value: '0.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate * 2
  states: {}
- name: symbol_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: taps
  id: variable
  parameters:
    value: '100'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '127'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/daniel/contracting/grcon23-ctf/dvbs2.sigmf-data
    type: byte
  states: {}
- name: blocks_file_source_2
  id: blocks_file_source
  parameters:
    file: /home/daniel/contracting/grcon23-ctf/plframes_all.c64
    repeat: 'False'
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1 - 1.237e-6
    freq_offset: '-2347.587 / samp_rate'
    noise_voltage: '0.01'
    seed: '173'
    taps: np.exp(1j * 0.817)
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: firdes.root_raised_cosine(0.9, samp_rate, samp_rate/2, rolloff, taps)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '0.48'
    decim: '1'
    gain: '0.7'
    samp_rate: '1'
    type: fir_filter_ccf
    width: '0.07'
    win: window.WIN_HAMMING
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_2, '0', fft_filter_xxx_0, '0']
- [channels_channel_model_0, '0', low_pass_filter_0, '0']
- [fft_filter_xxx_0, '0', channels_channel_model_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_interleaved_char_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
