options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: dvbs2_encode_8psk
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/daniel/contracting/grcon23-ctf/8psk910_plframes.c64
    type: complex
  states: {}
- name: blocks_file_source_1
  id: blocks_file_source
  parameters:
    file: /home/daniel/contracting/grcon23-ctf/bbframes_8psk.u8
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: dtv_dvb_bbscrambler_bb_0
  id: dtv_dvb_bbscrambler_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_bch_bb_0
  id: dtv_dvb_bch_bb
  parameters:
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvb_ldpc_bb_0
  id: dtv_dvb_ldpc_bb
  parameters:
    constellation: MOD_OTHER
    framesize2: FECFRAME_NORMAL
    rate3: C9_10
    standard: STANDARD_DVBS2
  states: {}
- name: dtv_dvbs2_interleaver_bb_0
  id: dtv_dvbs2_interleaver_bb
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_modulator_bc_0
  id: dtv_dvbs2_modulator_bc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    interpolation: INTERPOLATION_OFF
    rate1: C9_10
  states: {}
- name: dtv_dvbs2_physical_cc_0
  id: dtv_dvbs2_physical_cc
  parameters:
    constellation: MOD_8PSK
    framesize: FECFRAME_NORMAL
    goldcode: '0'
    pilots: PILOTS_OFF
    rate1: C9_10
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mod-phy
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: ldpc-int
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mod-phy
  states: {}

connections:
- [blocks_file_source_1, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', dtv_dvb_bbscrambler_bb_0, '0']
- [dtv_dvb_bbscrambler_bb_0, '0', dtv_dvb_bch_bb_0, '0']
- [dtv_dvb_bch_bb_0, '0', dtv_dvb_ldpc_bb_0, '0']
- [dtv_dvb_ldpc_bb_0, '0', virtual_sink_0, '0']
- [dtv_dvbs2_interleaver_bb_0, '0', dtv_dvbs2_modulator_bc_0, '0']
- [dtv_dvbs2_modulator_bc_0, '0', virtual_sink_1, '0']
- [dtv_dvbs2_physical_cc_0, '0', blocks_file_sink_1, '0']
- [virtual_source_0, '0', dtv_dvbs2_interleaver_bb_0, '0']
- [virtual_source_1, '0', dtv_dvbs2_physical_cc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
